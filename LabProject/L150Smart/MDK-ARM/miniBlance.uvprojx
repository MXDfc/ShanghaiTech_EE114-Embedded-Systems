# Keil uVision project miniBlance.uvprojx, settings and files
target miniBlance (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\HAREWARE\Inc;..\CONTROL;..\MPU6050\DMP;..\MPU6050\filter;..\MPU6050\IIC;..\MPU6050\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Inc/: Header.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group HAREWARE
    ../HAREWARE/: bsp_beep.c bsp_key.c bsp_led.c bsp_motor.c bsp_oled.c bsp_SysTick.c DataScope_DP.c encoder.c pstwo.c
  group CONTROL
    ../CONTROL/: control.c bluetooth.c capture.c ELE_CCD.c Lidar.c pid.c show.c smart_cruise.c lidar_mapping_nav.c
  group MPU6050
    ../MPU6050/MPU6050/: MPU6050.c
    ../MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MPU6050/filter/: filter.c
    ../MPU6050/IIC/: IOI2C.c
software components: CMSIS:CORE 4.3.0
